# add more qml, widgets packages
#IMAGE_INSTALL += " \
#"

#HACH Custom
IMAGE_INSTALL += " \
    zeromq \
    cppzmq \
    boost \
    \
    openssh-sftp-server \
    rsync \
    i2c-tools \
    \
    htop \
    \
    r1701-apps \
"
