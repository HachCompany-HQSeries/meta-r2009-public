#SOC_TOOLS_GPU_append_imxgpu = " \
#	imx-gpu-viv-tools \
#	imx-gpu-sdk \
#"
