# Provide our current default path where bitbake will serach for custom defconfig and patches.
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
