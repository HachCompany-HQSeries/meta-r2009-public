# HACH

#RDEPENDS_${PN} += " \
#    qtwebkit \
#    qtwebkit-qmlplugins \
#"
