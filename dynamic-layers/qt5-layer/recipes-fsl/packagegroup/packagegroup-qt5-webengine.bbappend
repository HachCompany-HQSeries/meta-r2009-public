# HACH

#RDEPENDS_${PN} += " \
#    qtwebengine \
#    qtwebengine-qmlplugins \
#    qtwebbrowser \
#"
