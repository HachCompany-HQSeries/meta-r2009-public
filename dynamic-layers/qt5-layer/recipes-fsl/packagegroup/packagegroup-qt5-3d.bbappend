# HACH Stuff

#RDEPENDS_${PN} += " \
#    qt3d \
#    qt3d-plugins \
#    qt3d-qmlplugins \
#    qt3d-tools \
#"
