# HACH Stuff

#RDEPENDS_${PN} += " \
#    qtsmarthome \
#    qt5ledscreen \
#    quitbattery \
#    qt5everywheredemo \
#    qt5nmapcarousedemo \
#    qt5nmapper \
#    cinematicexperience \
#    quitindicators \
#    qt5-demo-extrafiles \
#"
